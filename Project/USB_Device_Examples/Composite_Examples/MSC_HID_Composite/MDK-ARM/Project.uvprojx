# Keil uVision project Project.uvprojx, settings and files
target STM324xG-EVAL_USBD-HS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM324xG-EVAL_USBD-HS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_HS ,USE_ULPI_PHY
  c misc: --C99
  c include: ../inc;../../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../../../Libraries/STM32_USB_OTG_Driver/inc;../../../../../Libraries/STM32_USB_Device_Library/Core/inc;../../../../../Libraries/STM32_USB_Device_Library/Class/hid_msc_wrapper/inc;../../../../../Libraries/STM32_USB_Device_Library/Class/msc/inc;../../../../../Libraries/STM32_USB_Device_Library/Class/hid/inc;../../../../../Utilities/STM32_EVAL;../../../../../Utilities/STM32_EVAL/Common;../../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_ltdc.c stm32f4xx_fmc.c misc.c stm32f4xx_dma.c stm32f4xx_pwr.c stm32f4xx_syscfg.c stm32f4xx_sdio.c stm32f4xx_usart.c stm32f4xx_dma2d.c stm32f4xx_i2c.c stm32f4xx_fsmc.c stm32f4xx_exti.c stm32f4xx_gpio.c
  group App
    ../src/: stm32fxxx_it.c usbd_storage_msd.c usbd_desc.c app.c usbd_usr.c usb_bsp.c
  group USBDevice/Class/MSC
    ../../../../../Libraries/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c usbd_msc_bot.c
  group STM32F4xx/STM324xG_EVAL
    ../../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_sdio_sd.c
  group USBDevice/Class/HID-MSC
    ../../../../../Libraries/STM32_USB_Device_Library/Class/hid_msc_wrapper/src/: usbd_msc_hid_core.c
  group STM32F4xx
    ../src/: system_stm32f4xx.c
    ./: startup_stm32f40xx.s
  group USBDevice/Library
    ../../../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_ioreq.c usbd_core.c usbd_req.c
  group USBDrivers
    ../../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_dcd.c usb_dcd_int.c usb_core.c
  group Doc
    ../: readme.txt
  group USBDevice/Class/HID
    ../../../../../Libraries/STM32_USB_Device_Library/Class/hid/src/: usbd_hid_core.c
target STM324xG-EVAL_USBD-FS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: STM324xG-EVAL_USBD-FS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_FS
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0
