# Keil uVision project Project.uvprojx, settings and files
target STM324xG-EVAL_USBD-FS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM324xG-EVAL_USBD-FS +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_FS
  c misc: --C99
  c include: ../inc;../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../../Libraries/STM32_USB_OTG_Driver/inc;../../../../Libraries/STM32_USB_Device_Library/Core/inc;../../../../Libraries/STM32_USB_Device_Library/Class/cdc/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_sdio.c stm32f4xx_fsmc.c misc.c stm32f4xx_flash.c stm32f4xx_dma2d.c stm32f4xx_pwr.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_ltdc.c stm32f4xx_exti.c stm32f4xx_i2c.c
  group App
    ../src/: usbd_usr.c stm32fxxx_it.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c app.c
  group USBDrivers
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USBDevice/Class/CDC
    ../../../../Libraries/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core_loopback.c
  group Doc
    ../: readme.txt
  group USBDevice/Library
    ../../../../Libraries/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group STM32F4xx
    ../src/: system_stm32f4xx.c
    ./: startup_stm32f40xx.s
target STM324xG-EVAL_USBD-HS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: STM324xG-EVAL_USBD-HS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_USB_OTG_HS,USE_ULPI_PHY
  c misc: --C99
  c include: ../inc;../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../../Libraries/STM32_USB_OTG_Driver/inc;../../../../Libraries/STM32_USB_Device_Library/Core/inc;../../../../Libraries/STM32_USB_Device_Library/Class/cdc/inc;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0
