# Keil uVision project Project.uvprojx, settings and files
target STM324xG-EVAL_USBH-HS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM324xG-EVAL_USBH-HS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL,USE_USB_OTG_HS,USE_ULPI_PHY
  c misc: --C99
  c include: ../inc;../../../../Libraries/STM32_USB_HOST_Library/Class/HID/inc;../../../../Libraries/STM32_USB_HOST_Library/Class/MSC/inc;../../../../Libraries/STM32_USB_HOST_Library/Core/inc;../../../../Libraries/STM32_USB_OTG_Driver/inc;../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Include;../../../../Libraries/STM32F4xx_StdPeriph_Driver/inc;../../../../Utilities/STM32_EVAL;../../../../Utilities/STM32_EVAL/Common;../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL;../../../../Utilities/Third_Party/fat_fs/src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/Common/: lcd_log.c
  group STM32F4xx
    ../src/: system_stm32f4xx.c
    ./: startup_stm32f40xx.s
  group FAT_FS
    ../../../../Utilities/Third_Party/fat_fs/src/: ff.c
    ../../../../Utilities/Third_Party/fat_fs/src/option/: cc936.c
  group STM32F4xx/STM324xG_EVAL
    ../../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval_lcd.c stm324xg_eval.c
  group STM32F4xx/STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_sdio.c stm32f4xx_rcc.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_dma.c misc.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_syscfg.c stm32f4xx_dma2d.c stm32f4xx_tim.c stm32f4xx_fmc.c stm32f4xx_ltdc.c stm32f4xx_fsmc.c
  group USB_Host/Core
    ../../../../Libraries/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_ioreq.c usbh_hcs.c usbh_stdreq.c
  group USB_Host/Driver
    ../../../../Libraries/STM32_USB_OTG_Driver/src/: usb_hcd_int.c usb_hcd.c usb_core.c
  group App
    ../src/: usb_bsp.c usbh_usr.c stm32fxxx_it.c main.c
  group USB_Host/Class/MSC
    ../../../../Libraries/STM32_USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_fatfs.c usbh_msc_core.c usbh_msc_scsi.c
  group Doc
    ../: readme.txt
target STM324xG-EVAL_USBH-FS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: STM324xG-EVAL_USBH-FS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,USE_STM324xG_EVAL,USE_USB_OTG_FS
  c misc: --C99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 4.3.0
